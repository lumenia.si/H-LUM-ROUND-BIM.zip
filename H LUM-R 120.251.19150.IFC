Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM-R 120_150_200W-251.IFC
Time: 2023-10-23T06:51:58
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: HLUM-R 120_150_200W-251
In: Default Storey
SolidWorks Custom Properties - Description: PWR(120,150,200W);LUM.FLUX(19150-31450lm)
PSet_Mass_Property - Mass Measure: 1.80315; Area Measure: 0.167845 m2; Volume Measure: 0.00180315 m3
