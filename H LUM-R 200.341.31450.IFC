Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM-R 120_150_200W-341.IFC
Time: 2023-10-23T06:53:53
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: HLUM-R 120_150_200W-341
In: Default Storey
SolidWorks Custom Properties - Description: PWR(120,150,200W);LUM.FLUX(19150-31450lm)
PSet_Mass_Property - Mass Measure: 4.62733; Area Measure: 0.286867 m2; Volume Measure: 0.00462733 m3
